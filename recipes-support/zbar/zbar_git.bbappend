PACKAGECONFIG:append = " jpeg imagemagick"
