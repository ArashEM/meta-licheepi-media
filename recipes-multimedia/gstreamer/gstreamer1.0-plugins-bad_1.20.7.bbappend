PACKAGECONFIG:append = " v4l2codecs"
