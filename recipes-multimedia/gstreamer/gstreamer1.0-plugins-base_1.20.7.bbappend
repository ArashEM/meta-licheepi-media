PACKAGECONFIG:remove = " gles2"
